# Repository eltonchan1/my-first-macropad

File README.md:

this is myfirstmacroboard, meant to serve as an intro project to hardware and keyboards. there is lots to be improved upon, so please give me feedback, it would help a lot.
sources that helped me:
https://blueprint.hackclub.com
https://hackpad.hackclub.com/
https://github.com/palmacas/MacroBoard
chatgpt (for helping me understand stuff cuz im too slow to follow the hackpad tutorial sometimes)

## KiCad design PCB/myfirstmacropad.kicad_pcb

Parts:
D1, D2: SK6812MINI; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm
SW1, SW2, SW3, SW4: SW_Push; SW_Cherry_MX_1.00u_PCB
U1: XIAO-RP2040-DIP

Connections:
+5V: U1.14 (VBUS)
GND: SW1.1, SW2.1, SW3.1, SW4.1, U1.13 (GND)
unnamed: D1.3 (DIN), U1.5 (GPIO6/SDA)
unnamed: D1.1 (DOUT), D2.3 (DIN)
unnamed: D1.4 (VDD), D2.4 (VDD)
unnamed: D1.2 (VSS), D2.2 (VSS)
unnamed: SW1.2, U1.8 (GPIO1/RX)
unnamed: SW2.2, U1.9 (GPIO2/SCK)
unnamed: SW4.2, U1.11 (GPIO3/MOSI)
unnamed: SW3.2, U1.10 (GPIO4/MISO)

Board: 2 copper layers, 81.0 x 46.3 mm, 7 parts (0 on the bottom side), 9 nets.

## Commit log

2025-10-15 fusion things
2025-10-22 firmware main.py
2025-10-22 readme
2025-10-22 bom.csv
2025-10-22 Rename README.html to README.md
2025-10-22 Refactor BOM entries to comma-separated format
    Updated BOM format to use commas for item separation.
